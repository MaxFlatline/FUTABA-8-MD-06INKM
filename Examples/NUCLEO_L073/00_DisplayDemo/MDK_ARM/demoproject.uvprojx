# Keil uVision project demoproject.uvprojx, settings and files
target NUCLEO-L073RZ (6210000::V6.21::ARMCLANG)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demoproject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG
  c include: ..\..\..\..\Drivers\FUTABA_8_MD_06INKM_Driver\inc;..\..\..\..\Drivers\MCU_SPI\inc;..\..\..\..\Applications\00_DisplayDemo\inc
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../../../../Applications/00_DisplayDemo/src/: DisplayDemo.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L073RZTx/STCubeGenerated/Src/: main.c stm32l0xx_it.c
    ./RTE/Device/STM32L073RZTx/STCubeGenerated/Inc/: stm32l0xx_it.h
  group Driver\Futaba\8-MD-06INKM
    ../../../../Drivers/FUTABA_8_MD_06INKM_Driver/src/: 8_MD_06INKM.c
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, CMSIS Driver:SPI 1.0.0, Device:STM32Cube Framework:STM32CubeMX 1.12.2, Device:STM32Cube HAL 1.12.2
